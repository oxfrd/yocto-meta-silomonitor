FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://u-boot-bootdelay.cfg"
